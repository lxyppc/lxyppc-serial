# Keil uVision project polarSSL.uvproj, settings and files
target polarSSL (ARM-ADS)
  device: NUC120RE3AN Nuvoton
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x1FFFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: polarSSL +hex
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: oTime=1 OneElfS=1
  c define: USE_STDPERIPH_DRIVER
  c include: .\;..\library\NUC1xx\inc;..\library\NUC1xx\inc\driver;..\library\CMSIS\Device\Nuvoton\NUC1xx;..\..\include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --map --first='startup_NUC1xx.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS files
    ../library/CMSIS/Device/Nuvoton/NUC1xx/: system_NUC1xx.c
    ../library/CMSIS/Device/Nuvoton/NUC1xx/startup/arm/: startup_NUC1xx.s
  group Source files
    ../: main.c mem_util.c
  group Library files
    ../../library/: bignum.c mem.c bn_mul.c
