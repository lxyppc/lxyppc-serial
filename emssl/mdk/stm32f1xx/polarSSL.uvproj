# Keil uVision project polarSSL.uvproj, settings and files
target STM32 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: polarSSL +hex
  c flags: Optim=4 oTime=1 OneElfS=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER,HSE_VALUE=24000000
  c include: .;..\library\CMSIS\Device\ST\STM32F10x;..\library\CMSIS\Include;..\library\STM32F10x_StdPeriph_Driver\inc;..\..\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group App
    ../: main.c
  group System
    ./: system_stm32f10x_HSE_16MHz_sys_72MHz.c
    ../library/CMSIS/Device/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
  group algorithm
    ../../library/: bignum.c bn_mul.c mem.c
  group doc
    ./obj/: polarSSL.map
